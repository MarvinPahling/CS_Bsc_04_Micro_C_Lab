v.draw %e trace_buf0 trace_buf1 3.0 